<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F103RE6TR.ewp</path>
  </project>
  <batchBuild />
</workspace>
